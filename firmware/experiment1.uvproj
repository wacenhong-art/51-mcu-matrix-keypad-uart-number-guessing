# Keil uVision project experiment1.uvproj, settings and files
target GuessGame_LCD_LED (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: experiment1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c game.c display.c
